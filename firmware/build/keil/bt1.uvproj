# Keil uVision project bt1.uvproj, settings and files
target AMPM_CONTIKI_WISUN (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bt1 +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,AUTOSTART_ENABLE,__CC_ARM,USE_STDPERIPH_DRIVER,NETSTACK_CONF_WITH_IPV6,DEBUG_LEVEL = 3
  c include: ..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\contiki\core;..\..\contiki\platform\stm32f10x;..\..\contiki\cpu\arm\stm32f103;..\..\contiki\cpu\arm\common;..\..\contiki\core;..\..\contiki\core\sys;..\..\contiki\examples\hello-world;..\..\contiki\platform\stm32f10x\stm32-lib\drivers\spirit1\inc;..\..\contiki\platform\stm32f10x\stm32-lib\drivers\x_nucleo_ids01ax;..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\driver\ampm\stm32;..\..\contiki\platform\stm32f10x;..\..\ampm_lib;..\..\contiki\platform\stm32f10x\stm32-lib\drivers;..\..\contiki\core\net
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../../src/: main.c system_config.c
    ../../contiki/examples/hello-world/: hello-world1.c
  group Startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group driver
    ../../driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_flash.c misc.c
  group ampm_driver
    ../../src/: dbg.c
    ../../driver/ampm/stm32/: exti.c FlashProg.c spi.c uart1.c low_power_mode.c rtc.c adc.c
    ../../ampm_lib/lib/: ampm_sprintf.c ampm_ringbuf.c sys_time.c m_time.c sys_tick.c
  group contiki-core-dev
    ../../contiki/core/dev/: leds.c
  group contiki-platform
    ../../contiki/platform/stm32f10x/dev/: leds-arch.c cc1200-arch.c
    ../../contiki/platform/stm32f10x/: params.c watchdog.c
  group contiki-core-sys
    ../../contiki/core/sys/: etimer.c process.c arg.c timer.c autostart.c rtimer.c stimer.c energest.c ctimer.c compower.c
    ../../contiki/cpu/arm/stm32f103/: rtimer-arch.c
  group contiki-core-lib
    ../../contiki/core/lib/: list.c memb.c random.c aes-128.c assert.c ccm-star.c gcr.c ifft.c mmem.c petsciiconv.c print-stats.c ringbuf.c settings.c trickle-timer.c
  group contiki-net-ipv6
    ../../contiki/core/net/ipv6/: uip6.c uip-ds6.c uip-nd6.c sicslowpan.c uip-icmp6.c uip-ds6-route.c uip-ds6-nbr.c
  group contiki-net-ip
    ../../contiki/core/net/ip/: ip64-addr.c psock.c resolv.c simple-udp.c tcpip.c udp-socket.c uip-debug.c uiplib.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c
  group contiki-net-rpl
    ../../contiki/core/net/rpl/: rpl-ext-header.c rpl.c rpl-dag.c rpl-dag-root.c rpl-icmp6.c rpl-of0.c rpl-mrhof.c rpl-timers.c
  group contiki-core-net
    ../../contiki/core/net/: linkaddr.c nbr-table.c netstack.c packetbuf.c queuebuf.c
  group contiki-core-net-mac
    ../../contiki/core/net/mac/: frame802154.c framer-802154.c nullmac.c csma.c framer-nullmac.c frame802154e-ie.c mac.c mac-sequence.c nullrdc.c nullrdc-noframer.c phase.c
  group contiki-core-net-llsec
    ../../contiki/core/net/llsec/: nullsec.c anti-replay.c ccm-star-packetbuf.c
  group contiki-cpu-stm32f103
    ../../contiki/cpu/arm/stm32f103/: clock.c debug-uart.c
    ../../contiki/platform/stm32f10x/dev/: button-sensor.c
    ../../contiki/platform/stm32f10x/stm32-lib/drivers/: stm32f10x_io.c
  group radio
    ../../contiki/dev/cc1200/: cc1200.c cc1200-802154g-863-870-fsk-50kbps.c
  group contiki-core-net-rime
    ../../contiki/core/net/rime/: rimestats.c announcement.c broadcast-announcement.c chameleon.c channel.c broadcast.c chameleon-bitopt.c abc.c rime.c
  group contiki-core-net-sicslowmac
    ../../contiki/core/net/mac/sicslowmac/: sicslowmac.c
